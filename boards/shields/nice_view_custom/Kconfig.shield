## boards/shields/nice_view_custom/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_CUSTOM
    def_bool $(shields_list_contains,nice_view_custom)
```
